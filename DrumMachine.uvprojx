# Keil uVision project DrumMachine.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DrumMachine
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c app.c app.h UART.c UART.h cbfifo.c cbfifo.h IRQ.c IRQ.h I2C.c I2C.h CS43L22_DAC.h CS43L22_DAC.c I2S.c I2S.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
